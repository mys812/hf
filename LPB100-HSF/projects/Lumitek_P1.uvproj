# Keil uVision project Lumitek_P1.uvproj, settings and files
target Lumitek_P1 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: Lumitek_P1 +hex
  AfterMake: fromelf.exe --bin --output ./output/Lumitek_P1.bin ./output/Lumitek_P1.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/Lumitek_P1.bin ./output/Lumitek_P1_UPGARDE.bin
  c flags: OneElfS=1
  c define: __KEIL_MDK__
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.30/include/
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c app_main.c
    ../src/LumitekITO/src/: aes.c asyncMessage.c deviceGpio.c deviceMisc.c deviceUpgrade.c itoCommon.c itoMain.c localSocketUdp.c messageDispose.c serverSocketTcp.c socketSendList.c rn8209c.c lumTimeData.c lumTimer.c lumLog.c lumFactoryTest.c
  group libs
    ../sdk/1.30/libs/: LPB100Kernel.lib
