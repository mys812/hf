# Keil uVision project LPB100UExample.uvproj, settings and files
target LPBExample (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPBS2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPBS2W.bin ./output/LPBS2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPBS2W.bin ./output/LPBS2W_UPGARDE.bin
  c flags: Optim=1 OneElfS=1
  c define: __KEIL_MDK__ __LPB100U__
  c misc: --diag_suppress=494  --c99
  c include: ../../sdk/1.18/include/
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../: startup.c
    ../at/: attest.c
    ../gpio/: gpiotest.c
    ../netcallback/: callbacktest.c
    ../thread/: threadtest.c
    ../timer/: timertest.c
    ../file/: filetest.c
    ../uflash/: uflashtest.c
    ../socket/: sockettest.c
    ../ir/: irtest.c
    ../urlcallback/: url_callback_test.c
    ../wifi/: wifitest.c
    ../update/: updatetest.c
    ../uart/: uarttest.c
    ../audio/: audiotest.c
  group libs
    ../../sdk/1.18/libs/: LPB100UKernel.lib
