# Keil uVision project LPBS2W.uvproj, settings and files
target LPBS2W (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPBS2W +hex
  AfterMake: fromelf.exe --bin --output ./output/LPBS2W.bin ./output/LPBS2W.axf
  AfterMake: LPB100_IMG_Tools.exe ./output/LPBS2W.bin ./output/LPBS2W_UPGARDE.bin
  c flags: Optim=1 OneElfS=1
  c define: __KEIL_MDK__
  c misc: --diag_suppress=494  --c99
  c include: ../sdk/1.20/include/
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: startup.c app_main.c
    ../src/LumitekITO/src/: aes.c asyncMessage.c deviceGpio.c itoCommon.c itoMain.c localClientEvent.c localSocketUdp.c messageHeader.c serverSocketTcp.c
  group libs
    ../sdk/1.20/libs/: LPB100Kernel.lib
